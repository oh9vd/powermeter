# Repository oh9vd/powermeter

File README.md:

# PowerMeter Project (oh9vd)

Welcome to the oh9vd PowerMeter project! This repository contains comprehensive resources for both the hardware and software components of a power meter. The hardware design is managed using KiCad, while the software development is conducted using PlatformIO with support for Arduino on the ATmega328P microcontroller.

## Table of Contents

- [PowerMeter Project (oh9vd)](#powermeter-project-oh9vd)
  - [Table of Contents](#table-of-contents)
  - [Overview](#overview)
  - [Hardware](#hardware)
    - [Files](#files)
  - [Software](#software)
    - [Files](#files-1)
  - [Getting Started](#getting-started)
  - [Installation](#installation)
    - [Hardware](#hardware-1)
    - [Software](#software-1)
  - [Usage](#usage)
  - [Contributing](#contributing)
  - [License](#license)

## Overview

The PowerMeter project aims to create open-source HF Power and SWR (Standing Wave Ratio) measuring device. It includes detailed instructions and files for both hardware and software components. Tough, please **Note** that the hard ware part is only for reference and not intended to implement as is.

## Hardware

The hardware aspect is designed using **KiCad**, a powerful suite for electronic design automation. All relevant design files are stored in the `hardware` directory.

### Files

- `hardware/`: Contains all KiCad files including schematics, PCB layout, and custom libraries required for constructing the power meter reference implementation.

## Software

For software development, **PlatformIO** is used alongside Arduino to program the ATmega328P microcontroller. The source code and necessary configurations are provided in the `software/firmware` directory.

### Files

- `software/firmware/`: Houses the main firmware code and configuration files for PlatformIO.
- `libraries/`: External libraries required for firmware development.

## Getting Started

To get started with the project, clone this repository and ensure all dependencies are installed as per the guidelines in the [Installation](#installation) section.

```bash
git clone https://github.com/oh9vd/powermeter.git
cd powermeter
```

## Installation

### Hardware

1. Install **KiCad** from its [official website](https://www.kicad.org/).
2. Open the KiCad project files located in the `hardware/` folder to examine or modify the design.

### Software

1. Install **PlatformIO** via your preferred IDE extension or from the [PlatformIO website](https://platformio.org/).
2. Navigate to the `software/firmware` directory and open it in your PlatformIO-compatible IDE to access the firmware project.

## Usage

1. Create your own design of the power meter hardware (you can use the files in this repository as starting point if you wish).
2. Compile and upload the firmware to the ATmega328P using PlatformIO.
3. Connect the assembled device to a power source, and begin monitoring power consumption.

## Contributing

Contributions to enhance this project are welcome! Please read our [CONTRIBUTING.md](CONTRIBUTING.md) document for details on our contributing process.

## License

This project is licensed under the MIT License. For more information, see the [LICENSE](LICENSE) file.

## KiCad design hardware/detector/det-mcu/det-mcu.kicad_pcb

File hardware/README.md:

#Hardware for power meter

**Note** : This is old documentation of the boards that has gone trough many changes since. 
Please consider this as start point of your own hardware design and should be used only if you are willing to do so.
This document will stay in place for the time being until I have a better idea how to set up the boards with proper power meter functionality.
I am not going to implement this as it is too much work that would need more than one person to complete and there is no guarantee that all of us can do so.
If you are interested in hardware design for power meter, I will be glad to help with the implementation.

Parts:
C1, C2, C3, C4, C5: 10n; C_0603_HandSoldering
C6, C7, C8, C9, C10, C11, C12, C13: 2n; C_0603_HandSoldering
C14, C21: 10uF; TantalC_SizeA_EIA-3216_HandSoldering
C15, C16, C17, C18: 1n; C_0603_HandSoldering
C19, C20, C22, C23, C26, C29, C52, C53, C55, C57: 100n; C_0603_HandSoldering
C27, C28: 10u/16V; TantalC_SizeA_EIA-3216_HandSoldering
CON1: POWER JACK; JACK_ALIM
D1: 1N4001; SMA_Handsoldering
D4: 1N5819WS; D_SOD-323
F1: 0ZCJ0035AF2E; R_1210_HandSoldering
J1, J2: SMA; SMA_EDGE
J3, J4: CONN_01X15; Pin_Header_Straight_1x15
J5, J6: CONN_01X03; Pin_Header_Straight_1x03
J7: CONN_02X08; Pin_Header_Straight_2x08
J8: CONN_02X06; Pin_Header_Straight_2x06
J12: CONN_01X04; Pin_Header_Straight_1x04
L4: CMR; Pin_Header_Straight_2x02
P1: CONN_01X02; Pin_Header_Straight_1x02
R1, R2: 1k8; R_0603_HandSoldering
R4, R5, R8: 100; R_0603_HandSoldering
R9, R10, R11, R12, R13, R14, R15, R16: 50; R_0603_HandSoldering
S1: ACZ11BR4E; AZC11BRXE
U1: ARDUINO NANO; arduino_nano
U2: 74HC93; SOIC-14_3.9x8.7mm_Pitch1.27mm; DigiKey 568-2754-5-ND
U3: OLED_IIC; Pin_Header_Straight_1x04
U4: LTC2309; TSSOP-20_4.4x6.5mm_Pitch0.65mm
U5: ADR292; SOIC-8_3.9x4.9mm_Pitch1.27mm
U6: LM7805CT; uA7805

Connections:
/MCU/+12V: C26.1, C27.1, D1.2 (K), J4.15, J8.5, J8.6, J8.7, J8.8, U1.30 (VIN), U6.1 (IN)
/MCU/CH0: C6.2, C15.2, R9.1, U4.11 (CH0)
/MCU/CH1: C7.2, C15.1, R10.1, U4.12 (CH1)
/MCU/CH2: C8.2, C16.2, R11.1, U4.13 (CH2)
/MCU/CH3: C9.2, C16.1, R12.1, U4.14 (CH3)
/MCU/CH4: C10.2, C17.2, R13.1, U4.15 (CH4)
/MCU/CH5: C11.2, C17.1, R14.1, U4.16 (CH5)
/MCU/CH6: C12.2, C18.2, R15.1, U4.17 (CH6)
/MCU/CH7: C13.2, C18.1, R16.1, U4.18 (CH7)
/MCU/EA: C3.2, J3.5, R4.2, U1.5 (D2)
/MCU/EB: C5.1, J3.6, R8.2, U1.6 (D3)
/MCU/ES2: C4.2, J3.7, R5.2, U1.7 (D4)
/MCU/FIN/8: J3.8, J12.2, U1.8 (D5), U2.11 (Q3)
/MCU/Freq: U2.1 (CP1..3); also elsewhere on the board
/MCU/InC: J1.1 (RF), J5.2; also elsewhere on the board
/MCU/InV: J2.1 (RF), J6.2; also elsewhere on the board
/MCU/LEVEL: J4.4, J12.4, U1.19 (A0); also elsewhere on the board
/MCU/SCL: J4.9, R1.2, U1.24 (A5), U3.3 (SDA), U4.6 (SCL)
/MCU/SDA: J4.8, R2.2, U1.23 (A4), U3.4 (SCL), U4.7 (SDA)
/MCU/dBC: J7.2, R9.2; also elsewhere on the board
/MCU/dBCd: J7.6, R11.2; also elsewhere on the board
/MCU/dBV: J7.4, R10.2; also elsewhere on the board
/MCU/dBVd: J7.8, R12.2; also elsewhere on the board
GND: C1.1, C2.2, C3.1, C4.1, C5.2, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C19.1, C20.2, C21.2, C22.2, C23.2, C26.2, C27.2, C28.2, C29.2, C52.1, C53.1, C55.2, J1.2 (GND), J2.2 (GND), J3.4, J4.14, J5.1, J5.3, J6.1, J6.3, J7.1, J7.3, J7.5, J7.7, J7.9, J7.11, J7.13, J7.15, J8.9, J8.10, J8.11, J8.12, J12.1, J12.3, L4.4, S1.2 (C), S1.4 (S1), S1.7 (GND), S1.8 (GND), U1.4 (GND), U1.29 (GND), U2.2 (R0(1)), U2.3 (R0(2)), U2.10 (GND), U2.14 (CP0), U3.2 (GND), U4.2 (GND), U4.4 (AD0), U4.5 (AD1), U4.8 (GND), U4.9 (GND), U4.19 (COM), U4.20 (VREF), U5.4 (GND), U6.2 (GND); also elsewhere on the board
unnamed: CON1.1, F1.2
unnamed: D1.1 (A), P1.1
unnamed: C28.1, C29.1, D4.2 (A), U6.3 (OUT)
unnamed: J3.1, U1.1 (D1/TX)
unnamed: J3.2, U1.2 (D0/RX)
unnamed: J3.3, U1.3 (RESET)
unnamed: J3.9, U1.9 (D6)
unnamed: J3.10, U1.10 (D7)
unnamed: J3.11, U1.11 (D8)
unnamed: J3.12, U1.12 (D9)
unnamed: J3.13, U1.13 (D10)
unnamed: J3.14, U1.14 (D11/MOSI)
unnamed: J3.15, U1.15 (D12/MISO)
unnamed: J4.1, U1.16 (D13/SCK)
unnamed: J4.2, U1.17 (3V3)
unnamed: J4.3, U1.18 (AREF)
unnamed: J4.5, U1.20 (A1)
unnamed: J4.6, U1.21 (A2)
unnamed: J4.7, U1.22 (A3)
unnamed: J4.10, U1.25 (A6)
unnamed: J4.11, U1.26 (A7)
unnamed: J4.13, U1.28 (RESET)
unnamed: J7.10, R13.2
unnamed: J7.12, R14.2
unnamed: J7.14, R15.2
unnamed: J7.16, R16.2
unnamed: C52.2, C57.2, F1.1, L4.1
unnamed: C53.2, L4.2, P1.2
unnamed: C55.1, C57.1, CON1.2, CON1.3, L4.3
unnamed: R4.1, S1.1 (A)
unnamed: R8.1, S1.3 (B)
unnamed: R5.1, S1.6 (S2)
unnamed: C21.1, C22.1, U4.1 (REFC), U5.6 (VOUT)
VCC: C1.2, C2.1, C14.2, C19.2, C20.1, C23.1, D4.1 (K), J4.12, J8.1, J8.2, J8.3, J8.4, R1.1, R2.1, U1.27 (5V), U2.5 (VCC), U3.1 (Vcc), U4.3 (VDD), U4.10 (VDD), U5.2 (VIN); also elsewhere on the board

Notes on the sheet:
+4.096V
IIC ADDR = 0x08

Parts:
C24, C43: 10uF; TantalC_SizeA_EIA-3216_HandSoldering
C25, C36, C41, C44, C45, C46, C47, C48, C50, C51, C56: 100n; C_0603_HandSoldering
C30, C31, C32, C33, C35, C37, C39, C40, C54: 10n; C_0603_HandSoldering
C34, C38: 27p; C_0603_HandSoldering
C42: 1uF; TantalC_SizeA_EIA-3216_HandSoldering
C49: 47p; C_0603_HandSoldering
D2, D3: HSMS2805
J9, J10, J11: CONN_01X02; Pin_Header_Straight_1x02
L1, L3: 1mH; R_0805_HandSoldering
R17, R26, R27, R34: 25R; R_1210_HandSoldering
R18: 37R4; R_0603_HandSoldering
R19, R22, R28, R29, R42, R53, R60, R70: 0; R_0603_HandSoldering
R20, R21: 150; R_0603_HandSoldering
R23, R45: 52R3; R_1206_HandSoldering
R24, R25, R50, R51: 0; R_0603_HandSoldering; not fitted
R30, R36, R69: 10k; R_0603_HandSoldering
R31, R33, R47, R54: 4k7; R_0603_HandSoldering
R32, R49: 68; R_0603_HandSoldering
R35, R38, R55, R56, R64, R67, R71: 12k; R_0603_HandSoldering
R37, R39, R57, R58, R72: 20k; R_0603_HandSoldering
R40, R48, R52: 49R9; R_1210_HandSoldering
R41: 62; R_0603_HandSoldering
R43, R44, R59: 100; R_0603_HandSoldering
R61: 174; R_0603_HandSoldering
R62, R63: 4R7; R_0603_HandSoldering
R65: 120; R_1206_HandSoldering
R66: 110; R_0603_HandSoldering
R68: 220; R_0603_HandSoldering
U7, U10: AD8307; SOIC-8_3.9x4.9mm_Pitch1.27mm
U8A1, U8B1, U9A1, U9B1, U13A1, U13B1: LM358; SOIC-8_3.9x4.9mm_Pitch1.27mm
U11: AD8367; TSSOP-14_4.4x5mm_Pitch0.65mm
U12: ADCMP600; SC-70-5

Connections:
/MCU/Freq: R69.2, U12.1; also elsewhere on the board
/MCU/InC: R26.2; also elsewhere on the board
/MCU/InV: R40.2, R52.2; also elsewhere on the board
/MCU/LEVEL: R71.1, U13A1.1; also elsewhere on the board
/MCU/dBC: R38.1, U9A1.1; also elsewhere on the board
/MCU/dBCd: R35.1, U8A1.1; also elsewhere on the board
/MCU/dBV: R55.1, U9B1.7; also elsewhere on the board
/MCU/dBVd: R56.1, U8B1.7; also elsewhere on the board
/RF/+5V-B: C42.1, C43.1, C45.2, C56.1, L3.2, R62.1, R63.1, U11.2 (EN), U12.5 (Vcc)
/RF/+5V_filt: C24.2, C25.2, C33.2, C40.2, L1.2, U7.6 (ENB), U7.7 (VCC), U10.6 (ENB), U10.7 (VCC)
/RF/InCd: D2.3 (D1a), R25.2, R28.1, R32.1
/RF/InVd: D3.3 (D1a), R49.1, R51.2, R53.1
/RF/RSSI: C51.1, U11.5 (Gain), U11.6 (Det0), U13A1.3 (+)
/RF/amp: R34.1, R60.2, R65.2
GND: C24.1, C25.1, C31.2, C32.1, C33.1, C34.1, C35.1, C36.1, C38.1, C39.2, C40.1, C41.1, C42.2, C43.2, C45.1, C47.2, C48.2, C49.2, C50.2, C51.2, C54.1, C56.2, D2.2 (D2k), D3.2 (D2k), J9.1, J9.2, J10.1, J10.2, J11.1, J11.2, R20.2, R21.2, R23.2, R24.1, R25.1, R32.2, R36.1, R37.1, R39.1, R43.2, R44.2, R45.2, R49.2, R50.1, R51.1, R57.1, R58.1, R59.1, R65.1, R66.1, R68.1, R69.1, R72.1, U7.2 (GND), U8A1.4 (V-), U9A1.4 (V-), U10.2 (GND), U11.1 (Gnd), U11.4 (Mode), U11.7 (Gnd), U11.8 (Gnd), U11.14 (GND), U12.2 (GND), U13A1.4 (V-); also elsewhere on the board
unnamed: C30.1, R19.2
unnamed: C30.2, R18.1, R21.1, R23.1
unnamed: C37.1, R42.2
unnamed: C37.2, R41.1, R44.1, R45.1
unnamed: C44.1, R59.2
unnamed: C46.1, C49.1, R64.2, R67.2, R68.2
unnamed: C47.1, R63.2, U11.11 (VCC)
unnamed: C48.1, R62.2, U11.12 (VCC)
unnamed: C34.2, D2.1 (D1k), R31.2
unnamed: D2.4 (D2a), R33.2
unnamed: C38.2, D3.1 (D1k), R47.2
unnamed: D3.4 (D2a), R54.2
unnamed: R17.1, R18.2, R20.1
unnamed: R17.2, R26.1, R27.2, R34.2
unnamed: R24.2, R27.1, R28.2
unnamed: R40.1, R41.2, R43.1, R48.2
unnamed: R48.1, R50.2, R52.1, R53.2
unnamed: R60.1, R61.2, R66.2
unnamed: R19.1, U7.8 (+INP)
unnamed: C31.1, U7.1 (-INP)
unnamed: C36.2, U7.4 (OUT), U9A1.3 (+)
unnamed: R31.1, R33.1, U8A1.3 (+)
unnamed: R35.2, R37.2, U8A1.2 (-)
unnamed: C32.2, R22.1, U8A1.8 (V+)
unnamed: R47.1, R54.1, U8B1.5 (+)
unnamed: R56.2, R58.2, U8B1.6 (-)
unnamed: R38.2, R39.2, U9A1.2 (-)
unnamed: C35.2, R29.1, U9A1.8 (V+)
unnamed: R55.2, R57.2, U9B1.6 (-)
unnamed: R42.1, U10.8 (+INP)
unnamed: C39.1, U10.1 (-INP)
unnamed: C41.2, U9B1.5 (+), U10.4 (OUT)
unnamed: C50.1, U11.9 (DECL)
unnamed: C44.2, U11.13 (HPFL)
unnamed: R61.1, U11.3 (In)
unnamed: C46.2, U11.10 (Vout)
unnamed: R67.1, U12.4 (Vn)
unnamed: R64.1, U12.3 (Vp)
unnamed: R71.2, R72.2, U13A1.2 (-)
unnamed: C54.2, R30.2, R70.1, U13A1.8 (V+)
unnamed: U13B1.6 (-), U13B1.7
unnamed: R30.1, R36.2, U13B1.5 (+)
VCC: L1.1, L3.1, R22.2, R29.2, R70.2; also elsewhere on the board

Notes on the sheet:
Vo=Vi*(1+R38/R39)
-9.5dB
40mV/dB
-6dB
-11.5 dB
-9dB
Vo=Vi*A, A=(1+R55/R57) A=1+12/20=1.6 25 mV/dB * 1.6 = 40 mV/dB

Notes on the sheet:
36-9=27dBm~500mW
7-6=1dBm~1.3mW
RSSI (20mV/dB)
Voltage sample
65 dBm ~ 3kW
SOURCE
200 Ohm
1-9=-8dBm~0.16mW
2.5-6=-3.5dBm~0.45mW
Current sample
-29 dB
Intercept 0V @ -84 dBm Slope 0.025V / dB
7-9.5=2.5dBm~0.5mW
Tot = -73.5 dB
Vout^{fwd}
27-20=7dBm~5mW
Tot = -73 dB
freq
Vout^{ref}
2.5-11.5=-9dBm~0.13mW
LOAD
65-29=36dBm~4W
-9dB
MATCH -11.5 dB
AD8307
External -20dB
Splitter -9.5dB
DIODE (not used)
-6dB
Splitter -6dB
AD8367

Board: 2 copper layers, 100.0 x 100.0 mm, 158 parts (43 on the bottom side), 105 nets.

## KiCad design hardware/coupler/coupler.kicad_pcb

Board: 2 copper layers, 98.0 x 70.0 mm, 18 parts (0 on the bottom side), 7 nets.

Parts:
J1: TRX; uhf
J2: ANT; uhf
J3: FWD; coaxial
J4: REF; coaxial
R1, R2, R3, R4: 121; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder
R5, R6, R7, R8, R9, R10: 316; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder
R11, R12: 105; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder
U1, U2: 1:26; Coupler

Connections:
GND: J1.2 (Ext), J2.2 (Ext), J3.2 (Ext), J4.2 (Ext), R5.2, R6.2, R7.2, R8.2, R9.2, R10.2, R11.2, R12.2, U1.2 (GND), U1.5 (SHLD), U2.3 (CPL), U2.5 (SHLD)
unnamed: J1.1 (In), U1.1 (IN)
unnamed: J2.1 (In), U1.4 (OUT), U2.2 (GND)
unnamed: J3.1 (In), R1.1, R3.1, R11.1
unnamed: J4.1 (In), R2.1, R4.1, R12.1
unnamed: R1.2, R3.2, R5.1, R6.1, R7.1, U1.3 (CPL), U2.4 (OUT)
unnamed: R2.2, R4.2, R8.1, R9.1, R10.1, U2.1 (IN)

## Commit log

2025-04-19 Initial commit after reorganizing the project structure to have both hardware and software under same root.
2025-04-19 chore(gitignore): update firmware gitignore for misc directory
    Added `/misc/` to ensure the contents of this directory are not tracked by Git. This change helps prevent unnecessary files from being included in the repository, maintaining a cleaner project struct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
2025-04-19 moved to misc folder
2025-04-19 chore(gitignore): update ignored files for schematics and lock files
    Uncommented PDF and SVG file types in the gitignore to include them in the repository, possibly for documentation purposes. Added a rule to ignore lock files (*.lck) to prevent temporary files from a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
2025-04-19 Added the block diagram
2025-04-19 docs(firmware): update project directory name in README
    Renamed the directory from 'powermeter-firmware' to 'firmware' in the README file to reflect the current project structure accurately. This change ensures consistency between the documentation and th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
2025-04-19 Added svg plots for coupler and det-mcu
2025-04-19 minor changes
2025-04-19 refactor(display): streamline GitHub URL in display message
    Simplified the display output by replacing multiple lines of URL strings with a single, consolidated URL. This change enhances readability and ensures that users are directed to the main repository p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
2025-04-19 docs(core): add initial project documentation
    This commit introduces comprehensive documentation for the project with three new files: CODE_OF_CONDUCT.md, CONTRIBUTING.md, and README.md.
    1. CODE_OF_CONDUCT.md outlines expected behavior and enforcement guidelines based on the Contributor Covenant to ensure a welcoming and harassment-free community environment.
    2. CONTRIBUTING.md provides guidelines for reporting bugs, suggesting enhancements, submitting pull requests, and writing tests, encouraging community participation.
    3. README.md gives an overview of the PowerMeter project, including hardware and software components, with detailed instructions for getting started, installation, usage,
2025-04-19 refactor(firmware): remove obsolete Info class header file
    The Info class was determined to be unnecessary within the current architecture of the firmware. This commit removes the info.h header file, which defined the Info class primarily containing an unuse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
2025-04-19 refactor(rssi): simplify RSSI averaging logic in header file
    Removed the right bit-shift operation from the RSSI calculation process, simplifying the averaging logic. This change maintains efficiency by avoiding floating-point arithmetic while ensuring consist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
2025-04-19 refactor(firmware): remove unused Info module
    The Info module was included and instantiated but not utilized within the main.cpp file. This commit removes its inclusion and instantiation, streamlining the code and potentially improving memory us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
2025-04-20 Fixed the VIN to +12V
2025-04-22 docs(firmware): update and restructure README for clarity
    The README file of the PowerMeter firmware project has been updated to improve clarity and organization. Changes include a detailed project overview, a revised project structure section, consolidated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
